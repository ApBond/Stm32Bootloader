# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS\inc;..\Bootloader;.\Code\inc;.\lib\inc
  memory RVCT4: ROM 0x8000000 size 0x2400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: startup_stm32f10x_md_vl.s
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group Code
    ./Code/src/: main.c
  group Lib
    ./lib/src/: arp.c delay.c enc28j60.c net.c rcc.c tcp.c uart.c udp.c flash.c
