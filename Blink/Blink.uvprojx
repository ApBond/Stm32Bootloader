# Keil uVision project Blink.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blink +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=C:\STM32_Files\project\Blink\Objects\Blink.bin C:\STM32_Files\project\Blink\Objects\Blink.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Code\inc;.\lib\inc
  memory RVCT4: ROM 0x8002000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Code
    ./Code/src/: main.c
  group Lib
    ./lib/src/: delay.c enc28j60.c flash.c net.c rcc.c tcp.c arp.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
